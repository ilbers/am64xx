SRC_URI = "file://postinst"

inherit dpkg-raw
