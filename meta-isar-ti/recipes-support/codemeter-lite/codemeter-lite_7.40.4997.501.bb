inherit dpkg-prebuilt

# This can be some local deb file or URL to the remote one
SRC_URI = "file://codemeter-lite_7.40.4997.501_arm64.deb"
